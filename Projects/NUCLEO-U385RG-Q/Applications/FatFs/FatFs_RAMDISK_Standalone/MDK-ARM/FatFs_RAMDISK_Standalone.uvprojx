# Keil uVision project FatFs_RAMDISK_Standalone.uvprojx, settings and files
target FatFs_RAMDISK_Standalone (6210000::V6.21::ARMCLANG)
  device: STM32U385RGTxQ STMicroelectronics
  pack: Keil.STM32U3xx_DFP.1.0.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x20030000-0x2003FFFF) IROM(0x08000000-0x80FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: FatFs_RAMDISK_Standalone +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U385xx
  c include: ../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include;../../../../../../Drivers/CMSIS/Include;..\Core\Inc;..\FATFS\App;..\FATFS\Target;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\source;..\..\..\..\..\..\Drivers\BSP\STM32U3xx_Nucleo;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\source\drivers\sram
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x20030000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32u385xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32u3xx_hal_msp.c stm32u3xx_it.c
  group Application/User/FatFs/App
    ../FATFS/App/: app_fatfs.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U3xx_Nucleo
    ../../../../../../Drivers/BSP/STM32U3xx_Nucleo/: stm32u3xx_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u3xx.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal_tim.c stm32u3xx_hal_tim_ex.c stm32u3xx_hal_cortex.c stm32u3xx_hal_icache.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal.c stm32u3xx_hal_exti.c stm32u3xx_hal_uart.c stm32u3xx_hal_uart_ex.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/source/: diskio.c ff.c ff_gen_drv.c ffunicode.c ffsystem_baremetal.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/source/drivers/sram/: sram_diskio.c
software components: CMSIS:CORE 5.6.0
