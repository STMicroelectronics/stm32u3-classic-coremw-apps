# IAR project FatFs_RAMDISK_Standalone.ewp, settings and files
configuration FatFs_RAMDISK_Standalone (ARM, debug)
  General.OGChipSelectEditMenu: STM32U385RG ST STM32U385RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32U385xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ../FATFS/App; ../FATFS/Target; ../Core/Inc; ../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include; ../../../../../../Middlewares/Third_Party/FatFs/source; C:\git\U3_Classique_MW\Firmware\Middlewares\Third_Party\FatFs\source\drivers\sram; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32U3xx_Nucleo; ../../../../../../Drivers/BSP/Components; ../../../../../../Drivers/BSP/Components/Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FatFs_RAMDISK_Standalone.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32u385xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u385xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32u3xx_hal_msp.c stm32u3xx_it.c
  group Application/User/FATFS/App
    ../FATFS/App/: app_fatfs.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U3xx_Nucleo
    ../../../../../../Drivers/BSP/STM32U3xx_Nucleo/: stm32u3xx_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u3xx.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal.c stm32u3xx_hal_cortex.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_exti.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_gtzc.c stm32u3xx_hal_i2c.c stm32u3xx_hal_i2c_ex.c stm32u3xx_hal_icache.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_tim.c stm32u3xx_hal_tim_ex.c stm32u3xx_hal_uart.c stm32u3xx_hal_uart_ex.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/source/: diskio.c ff.c ff_gen_drv.c ffsystem_baremetal.c ffunicode.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/source/drivers/sram/: sram_diskio.c
