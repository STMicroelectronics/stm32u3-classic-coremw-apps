# IAR project CDC_Standalone.ewp, settings and files
configuration CDC_Standalone (ARM, debug)
  General.OGChipSelectEditMenu: STM32U385RG ST STM32U385RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32U385xx; USE_HAL_DRIVER; USBD_LPM_SLEEP_CONFIG; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\USB_Device\App; ..\USB_Device\Target; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U3xx\Include; ..\..\..\..\..\..\Drivers\STM32U3xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32U3xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32u385xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u385xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32u3xx_hal_msp.c stm32u3xx_it.c
  group Application/User/USB_Device/App
    ../USB_Device/App/: usb_device.c usbd_cdc_if.c usbd_desc.c
  group Application/User/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Doc
    ../: README.md
  group Drivers/BSP
    ../../../../../../Drivers/BSP/STM32U3xx_Nucleo/: stm32u3xx_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u3xx.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal.c stm32u3xx_hal_adc.c stm32u3xx_hal_adc_ex.c stm32u3xx_hal_cortex.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_exti.c stm32u3xx_hal_gpio.c stm32u3xx_hal_i2c.c stm32u3xx_hal_i2c_ex.c stm32u3xx_hal_icache.c stm32u3xx_hal_pcd.c stm32u3xx_hal_pcd_ex.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_tim.c stm32u3xx_hal_tim_ex.c stm32u3xx_hal_uart.c stm32u3xx_hal_uart_ex.c stm32u3xx_hal_usart.c stm32u3xx_hal_usart_ex.c stm32u3xx_ll_rcc.c stm32u3xx_ll_usart.c stm32u3xx_ll_usb.c
  group Middlewares/STM32_USBD_Library/Class/CDC
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
